# Keil uVision project S32K144_App_Code.uvprojx, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: S32K144UFxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S32K144_App_Debug +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c include: .\;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS\portable\MemMang;.\FreeRTOS\portable\RVDS;.\FreeRTOS\portable;.\01_Bsp;.\02_Hal;.\03_Uds;.\04_App
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144UFxxxLLx\S32K144_64_flash_Debug.sct
  group FreeRTOS_src
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_protable
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS_conf
    ./FreeRTOS/: FreeRTOSConfig.h
  group 01_Bsp
    ./01_Bsp/: clocks_and_modes.c clocks_and_modes.h include.h main.c os_hooks.c
  group 02_Hal
    ./02_Hal/: hal_gpio.c hal_gpio.h hal_can.c hal_can.h hal_flash.c hal_flash.h hal_dma.c hal_dma.h
  group 03_Uds
    ./03_Uds/: uds_service.c uds_service.h uds_tp.c uds_tp.h
target App (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: S32K144UFxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: as above
  output: S32K144_App_Code +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144UFxxxLLx\S32K144_64_flash_App.sct
software components: CMSIS:CORE 5.3.0, Device:SDK Driver:Flash 1.0.0, Device:SDK Driver:Interrupt 1.0.0, Device:Startup 2.0.0
