# Keil uVision project S32K144_BootLoader_Code__.uvprojx, settings and files
target J-Link (6190000::V6.19::ARMCLANG)
  device: S32K144UFxxxLLx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S32K144_BootLoader_Code__ +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: .\;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\FreeRTOS\portable\MemMang;.\FreeRTOS\portable\RVDS;.\FreeRTOS\portable;.\01_Source;.\02_Hal
  memory RVCT4: ROM 0x0 size 0x7fff
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144UFxxxLLx\S32K144_64_flash.sct
  group 01_Source
    ./01_Source/: clocks_and_modes.c clocks_and_modes.h include.h main.c
  group 02_Hal
    ./02_Hal/: hal_flash.c hal_flash.h
software components: CMSIS:CORE 5.3.0, Device:SDK Driver:Flash 1.0.0, Device:SDK Driver:Interrupt 1.0.0, Device:Startup 2.0.0
